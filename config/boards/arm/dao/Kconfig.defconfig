## config/boards/arm/dao/Kconfig.defconfig
```kconfig
# Обязательно для ZMK main после декабря 2024
config ZMK_BOARD_COMPAT
    default y
```
